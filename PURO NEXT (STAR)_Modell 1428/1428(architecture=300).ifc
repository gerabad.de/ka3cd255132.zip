Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_47/temp/tmp_2780_189_aqmwK/format_1/1428(architecture=300).ifc
Time: 2025-08-11T06:30:28
Made in: PARTsolutions

# IfcProject, 1428(architecture=300)
Description: PURO NEXT

# IfcDiscreteAccessory, 1428(architecture=300)
In: BUILDING
Description: 1428(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 1428
ePset_PARTsolutions - NB: 1428(architecture=300); NN: 1428; NT: PURO NEXT; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 1428(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 1428; B: 1428.png; C: PURO NEXT; E: KALDEWEI; EF000049: 1800; EF004567: 800
